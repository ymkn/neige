# Repository ymkn/neige

File README.md:

# Neige

A compact 3-rows 30% keyboard with 12-column row staggered layout in 12.75u width.

## Default Layout

You can also customize the layout using [Vial](https://get.vial.today/).

## Build Guide

See [Build Guide](https://ymkn.github.io/buildguide/neige.html).

## License

This project is licensed under the MIT License, see the [LICENSE file](LICENSE) for details.

However, this does not apply to logo data (image files, KiCAD footprints, etc.) included in the resources of this project.

## KiCad design KiCAD/PCB/Neige_PCB.kicad_pcb

Parts:
BTN_BOOT1: SW_Push; SW_Push_1P1T_XKB_TS-1187A; JLCPCB Part # C318884
C3, C4: 10uF; C_0603_1608Metric; JLCPCB Part # C19702
C5, C6, C7, C8, C10: 100nF; C_0402_1005Metric; JLCPCB Part # C1525
C9: 10nF; C_0402_1005Metric; JLCPCB Part # C15195
C11, C12: 4.7uF; C_0402_1005Metric; JLCPCB Part # C23733
C13: 1uF; C_0402_1005Metric; JLCPCB Part # C52923
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36: 1N4148W; D_SOD-123; LCSC Parts # C81598
FB1: FerriteBead; L_0603_1608Metric; JLCPCB Part # C394426
J1: TYPE-C 16PIN 2MD(073); USB_C_Receptacle_HRO_TYPE-C-31-M-12; JLCPCB Part # C2765186
R2, R3: 5.1K; R_0402_1005Metric; JLCPCB Part # C25905
R4: 10K; R_0402_1005Metric; JLCPCB Part # C25744
SW1, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW36: SW_Push; SW_choc_v2_1u; LCSC Parts # C18212911
SW2: SW_Push; SW_choc_v2_1.25u; LCSC Parts # C18212911
SW3, SW34: SW_Push; SW_choc_v2_1.75u; LCSC Parts # C18212911
SW35: SW_Push; SW_choc_v2_1.5u; LCSC Parts # C18212911
U1: USBLC6-2SC6; SOT-23-6; JLCPCB Part # C7519
U2: XC6206P332MR; SOT-23-3; JLCPCB Part # C5446
U3: STM32F072CBU6; UFQFPN48-7x7mm; JLCPCB Part # C92504

Connections:
+3V3: BTN_BOOT1.1, C4.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, U2.2 (VO), U3.1 (VBAT), U3.9 (VDDA), U3.24 (VDD), U3.36 (VDDIO2), U3.48 (VDD)
+5V: C3.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U1.5 (VBUS), U2.3 (VI)
BOOT: BTN_BOOT1.2, R4.2, U3.44 (BOOT0)
COL0: SW1.1, SW2.1, SW3.1, U3.31 (PA10)
COL1: SW4.1, SW5.1, SW6.1, U3.30 (PA9)
COL2: SW7.1, SW8.1, SW9.1, U3.29 (PA8)
COL3: SW10.1, SW11.1, SW12.1, U3.27 (PB14)
COL4: SW13.1, SW14.1, SW15.1, U3.25 (PB12)
COL5: SW16.1, SW17.1, SW18.1, U3.22 (PB11)
COL6: SW19.1, SW20.1, SW21.1, U3.21 (PB10)
COL7: SW22.1, SW23.1, SW24.1, U3.19 (PB1)
COL8: SW25.1, SW26.1, SW27.1, U3.18 (PB0)
COL9: SW28.1, SW29.1, SW30.1, U3.17 (PA7)
COL10: SW31.1, SW32.1, SW33.1, U3.16 (PA6)
COL11: SW34.1, SW35.1, SW36.1, U3.15 (PA5)
GND: C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, FB1.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), R2.1, R3.2, R4.1, U1.2 (GND), U2.1 (GND), U3.8 (VSSA), U3.23 (VSS), U3.35 (VSS), U3.47 (VSS), U3.49 (VSS)
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW10.2
unnamed: D11.2 (A), SW11.2
unnamed: D12.2 (A), SW12.2
unnamed: D13.2 (A), SW13.2
unnamed: D14.2 (A), SW14.2
unnamed: D15.2 (A), SW15.2
unnamed: D16.2 (A), SW16.2
unnamed: D17.2 (A), SW17.2
unnamed: D18.2 (A), SW18.2
unnamed: D19.2 (A), SW19.2
unnamed: D20.2 (A), SW20.2
unnamed: D21.2 (A), SW21.2
unnamed: D22.2 (A), SW22.2
unnamed: D23.2 (A), SW23.2
unnamed: D24.2 (A), SW24.2
unnamed: D25.2 (A), SW25.2
unnamed: D26.2 (A), SW26.2
unnamed: D27.2 (A), SW27.2
unnamed: D28.2 (A), SW28.2
unnamed: D29.2 (A), SW29.2
unnamed: D30.2 (A), SW30.2
unnamed: D31.2 (A), SW31.2
unnamed: D32.2 (A), SW32.2
unnamed: D33.2 (A), SW33.2
unnamed: D34.2 (A), SW34.2
unnamed: D35.2 (A), SW35.2
unnamed: D36.2 (A), SW36.2
unnamed: J1.A5 (CC1), R3.1
unnamed: J1.B5 (CC2), R2.2
unnamed: FB1.1, J1.S1 (SHIELD)
unnamed: C5.1, U3.7 (NRST)
ROW0: D1.1 (K), D4.1 (K), D7.1 (K), D10.1 (K), D13.1 (K), D16.1 (K), D19.1 (K), D22.1 (K), D25.1 (K), D28.1 (K), D31.1 (K), D34.1 (K), U3.26 (PB13)
ROW1: D2.1 (K), D5.1 (K), D8.1 (K), D11.1 (K), D14.1 (K), D17.1 (K), D20.1 (K), D23.1 (K), D26.1 (K), D29.1 (K), D32.1 (K), D35.1 (K), U3.20 (PB2)
ROW2: D3.1 (K), D6.1 (K), D9.1 (K), D12.1 (K), D15.1 (K), D18.1 (K), D21.1 (K), D24.1 (K), D27.1 (K), D30.1 (K), D33.1 (K), D36.1 (K), U3.14 (PA4)
USB_D+: J1.A6 (D+), J1.B6 (D+), U1.1 (I/O1), U1.6 (I/O1), U3.33 (PA12)
USB_D-: J1.A7 (D-), J1.B7 (D-), U1.3 (I/O2), U1.4 (I/O2), U3.32 (PA11)

Notes on the sheet:
※MCU内蔵クロック使用
Crystal
MCU
Key Matrix
※for VDDA
※MCU近傍
※USBコネクタ近傍
BOOT/RESET
※3.3V電源ピン近傍
※差動信号、配線長さ合わせる
USB / Power
※リセットボタン実装無し

Board: 2 copper layers, 257.0 x 57.1 mm, 92 parts (92 on the bottom side), 61 nets.

File KiCAD/PCB/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
BTN_BOOT1,SW_Push_1P1T_XKB_TS-1187A,1,SW_Push,C318884
"C10, C5, C6, C7, C8",0402,5,100nF,C1525
"C11, C12",0402,2,4.7uF,C23733
C13,0402,1,1uF,C52923
"C3, C4",0603,2,10uF,C19702
C9,0402,1,10nF,C15195
"D1, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D2, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D3, D30, D31, D32, D33, D34, D35, D36, D4, D5, D6, D7, D8, D9",D_SOD-123,36,1N4148W,C81598
FB1,0603,1,FerriteBead,C394426
J1,USB_C_Receptacle_HRO_TYPE-C-31-M-12,1,TYPE-C 16PIN 2MD(073),C2765186
"R2, R3",0402,2,5.1K,C25905
R4,0402,1,10K,C25744
"SW1, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW36, SW4, SW5, SW6, SW7, SW8, SW9",SW_choc_v2_1u,32,SW_Push,
SW2,SW_choc_v2_1.25u,1,SW_Push,
"SW3, SW34",SW_choc_v2_1.75u,2,SW_Push,
SW35,SW_choc_v2_1.5u,1,SW_Push,
U1,SOT-23-6,1,USBLC6-2SC6,C7519
U2,SOT-23-3,1,XC6206P332MR,C5446
U3,UFQFPN48-7x7mm,1,STM32F072CBU6,C92504

## KiCad design KiCAD/PCB_GLP/Neige_PCB_GLP.kicad_pcb

Parts:
BTN_BOOT1: SW_Push; SW_Push_1P1T_XKB_TS-1187A; JLCPCB Part # C318884
C3, C4: 10uF; C_0603_1608Metric; JLCPCB Part # C19702
C5, C6, C7, C8, C10: 100nF; C_0402_1005Metric; JLCPCB Part # C1525
C9: 10nF; C_0402_1005Metric; JLCPCB Part # C15195
C11, C12: 4.7uF; C_0402_1005Metric; JLCPCB Part # C23733
C13: 1uF; C_0402_1005Metric; JLCPCB Part # C52923
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36: 1N4148W; D_SOD-123; LCSC Parts # C81598
FB1: FerriteBead; L_0603_1608Metric; JLCPCB Part # C394426
J1: TYPE-C 16PIN 2MD(073); USB_C_Receptacle_HRO_TYPE-C-31-M-12; JLCPCB Part # C2765186
R2, R3: 5.1K; R_0402_1005Metric; JLCPCB Part # C25905
R4: 10K; R_0402_1005Metric; JLCPCB Part # C25744
SW1, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW36: SW_Push; SW_MX_GLP3_1u; LCSC Parts # C18212911
SW2: SW_Push; SW_MX_GLP3_1.25u; LCSC Parts # C18212911
SW3, SW34: SW_Push; SW_MX_GLP3_1.75u; LCSC Parts # C18212911
SW35: SW_Push; SW_MX_GLP3_1.5u; LCSC Parts # C18212911
U1: USBLC6-2SC6; SOT-23-6; JLCPCB Part # C7519
U2: XC6206P332MR; SOT-23-3; JLCPCB Part # C5446
U3: STM32F072CBU6; UFQFPN48-7x7mm; JLCPCB Part # C92504

Connections:
+3V3: BTN_BOOT1.1, C4.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, U2.2 (VO), U3.1 (VBAT), U3.9 (VDDA), U3.24 (VDD), U3.36 (VDDIO2), U3.48 (VDD)
+5V: C3.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U1.5 (VBUS), U2.3 (VI)
BOOT: BTN_BOOT1.2, R4.2, U3.44 (BOOT0)
COL0: SW1.2, SW2.2, SW3.2, U3.31 (PA10)
COL1: SW4.2, SW5.2, SW6.2, U3.30 (PA9)
COL2: SW7.2, SW8.2, SW9.2, U3.29 (PA8)
COL3: SW10.2, SW11.2, SW12.2, U3.27 (PB14)
COL4: SW13.2, SW14.2, SW15.2, U3.25 (PB12)
COL5: SW16.2, SW17.2, SW18.2, U3.22 (PB11)
COL6: SW19.2, SW20.2, SW21.2, U3.21 (PB10)
COL7: SW22.2, SW23.2, SW24.2, U3.19 (PB1)
COL8: SW25.2, SW26.2, SW27.2, U3.18 (PB0)
COL9: SW28.2, SW29.2, SW30.2, U3.17 (PA7)
COL10: SW31.2, SW32.2, SW33.2, U3.16 (PA6)
COL11: SW34.2, SW35.2, SW36.2, U3.15 (PA5)
GND: C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, FB1.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), R2.1, R3.2, R4.1, U1.2 (GND), U2.1 (GND), U3.8 (VSSA), U3.23 (VSS), U3.35 (VSS), U3.47 (VSS), U3.49 (VSS)
unnamed: D1.2 (A), SW1.1
unnamed: D2.2 (A), SW2.1
unnamed: D3.2 (A), SW3.1
unnamed: D4.2 (A), SW4.1
unnamed: D5.2 (A), SW5.1
unnamed: D6.2 (A), SW6.1
unnamed: D7.2 (A), SW7.1
unnamed: D8.2 (A), SW8.1
unnamed: D9.2 (A), SW9.1
unnamed: D10.2 (A), SW10.1
unnamed: D11.2 (A), SW11.1
unnamed: D12.2 (A), SW12.1
unnamed: D13.2 (A), SW13.1
unnamed: D14.2 (A), SW14.1
unnamed: D15.2 (A), SW15.1
unnamed: D16.2 (A), SW16.1
unnamed: D17.2 (A), SW17.1
unnamed: D18.2 (A), SW18.1
unnamed: D19.2 (A), SW19.1
unnamed: D20.2 (A), SW20.1
unnamed: D21.2 (A), SW21.1
unnamed: D22.2 (A), SW22.1
unnamed: D23.2 (A), SW23.1
unnamed: D24.2 (A), SW24.1
unnamed: D25.2 (A), SW25.1
unnamed: D26.2 (A), SW26.1
unnamed: D27.2 (A), SW27.1
unnamed: D28.2 (A), SW28.1
unnamed: D29.2 (A), SW29.1
unnamed: D30.2 (A), SW30.1
unnamed: D31.2 (A), SW31.1
unnamed: D32.2 (A), SW32.1
unnamed: D33.2 (A), SW33.1
unnamed: D34.2 (A), SW34.1
unnamed: D35.2 (A), SW35.1
unnamed: D36.2 (A), SW36.1
unnamed: J1.A5 (CC1), R3.1
unnamed: J1.B5 (CC2), R2.2
unnamed: FB1.1, J1.S1 (SHIELD)
unnamed: C5.1, U3.7 (NRST)
ROW0: D1.1 (K), D4.1 (K), D7.1 (K), D10.1 (K), D13.1 (K), D16.1 (K), D19.1 (K), D22.1 (K), D25.1 (K), D28.1 (K), D31.1 (K), D34.1 (K), U3.26 (PB13)
ROW1: D2.1 (K), D5.1 (K), D8.1 (K), D11.1 (K), D14.1 (K), D17.1 (K), D20.1 (K), D23.1 (K), D26.1 (K), D29.1 (K), D32.1 (K), D35.1 (K), U3.20 (PB2)
ROW2: D3.1 (K), D6.1 (K), D9.1 (K), D12.1 (K), D15.1 (K), D18.1 (K), D21.1 (K), D24.1 (K), D27.1 (K), D30.1 (K), D33.1 (K), D36.1 (K), U3.14 (PA4)
USB_D+: J1.A6 (D+), J1.B6 (D+), U1.1 (I/O1), U1.6 (I/O1), U3.33 (PA12)
USB_D-: J1.A7 (D-), J1.B7 (D-), U1.3 (I/O2), U1.4 (I/O2), U3.32 (PA11)

Notes on the sheet:
※MCU内蔵クロック使用
Crystal
MCU
Key Matrix
※for VDDA
※MCU近傍
※USBコネクタ近傍
BOOT/RESET
※3.3V電源ピン近傍
※差動信号、配線長さ合わせる
USB / Power
※リセットボタン実装無し

Board: 2 copper layers, 257.0 x 57.1 mm, 92 parts (92 on the bottom side), 61 nets.

File KiCAD/PCB_GLP/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
BTN_BOOT1,SW_Push_1P1T_XKB_TS-1187A,1,SW_Push,C318884
"C10, C5, C6, C7, C8",0402,5,100nF,C1525
"C11, C12",0402,2,4.7uF,C23733
C13,0402,1,1uF,C52923
"C3, C4",0603,2,10uF,C19702
C9,0402,1,10nF,C15195
"D1, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D2, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D3, D30, D31, D32, D33, D34, D35, D36, D4, D5, D6, D7, D8, D9",D_SOD-123,36,1N4148W,C81598
FB1,0603,1,FerriteBead,C394426
J1,USB_C_Receptacle_HRO_TYPE-C-31-M-12,1,TYPE-C 16PIN 2MD(073),C2765186
"R2, R3",0402,2,5.1K,C25905
R4,0402,1,10K,C25744
"SW1, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW36, SW4, SW5, SW6, SW7, SW8, SW9",SW_MX_GLP3_1u,32,SW_Push,C41430893
SW2,SW_MX_GLP3_1.25u,1,SW_Push,C41430893
"SW3, SW34",SW_MX_GLP3_1.75u,2,SW_Push,C41430893
SW35,SW_MX_GLP3_1.5u,1,SW_Push,C41430893
U1,SOT-23-6,1,USBLC6-2SC6,C7519
U2,SOT-23-3,1,XC6206P332MR,C5446
U3,UFQFPN48-7x7mm,1,STM32F072CBU6,C92504

## Commit log

2025-04-30 試作版ビルドガイドの追加
2025-05-02 vilファイルのロード手順を追加
2025-05-11 プロトタイプ版の寸法資料を追加
2025-06-13 submoduleの追加
2025-06-13 基板とファームウェア
2025-07-25 v1.0
2025-07-29 デフォルトキーマップ変更
2025-07-29 デフォルトvilファイルの追加
2025-07-29 デフォるキーマップの微修正
2025-08-31 デフォルトキーマップの微修正
2025-08-31 パスコン見直し版
2025-08-31 backup等除外
2025-08-31 Gateron LP 3.0版
2025-08-31 寸法公開用SVGの追加
2026-04-19 firmware書き込み手順の修正 #1
